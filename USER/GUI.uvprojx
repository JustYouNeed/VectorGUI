# Keil uVision project GUI.uvprojx, settings and files
target GUI (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VectorFly +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,ARM_MATH_CM4
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\BSP\inc;..\APP\inc;..\USB\USB_APP\interface;..\USB\USB_CORE\inc;..\USB\USB_DEVICE\Core\inc;..\USB\USB_DEVICE\Class\cdc\inc;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CONFIG\inc;..\COMMON\inc;..\GUI\core\inc;..\GUI\widget\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_pwr.c stm32f4xx_rtc.c
  group CONFIG
    ../CONFIG/inc/: stm32f4xx_conf.h FreeRTOSConfig.h config.h
  group COMMON
    ../COMMON/src/: filter.c pid.c sort.c i2cdrv.c
  group BSP
    ../BSP/src/: bsp.c bsp_rcc.c bsp_timer.c bsp_led.c bsp_key.c bsp_oled.c
  group APP
    ../APP/src/: app_led.c powerManger.c display.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c event_groups.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group GUI_CORE
    ../GUI/core/src/: gui_basic.c gui_drv.c gui_core.c gui_win.c gui_widget.c gui_font.c gui_key.c gui_mem.c
  group GUI_WIDGET
    ../GUI/widget/src/: gui_button.c gui_checkbox.c gui_iconview.c gui_list.c gui_menu.c gui_scrollbar.c gui_progbar.c gui_text.c
